# Keil uVision project RC_Calibration.uvproj, settings and files
target RC_Calibration (ARM-ADS)
  device: STM32F100C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RC_Calibration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_LD
  c include: ..\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\\Libraries\CMSIS\Core\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c
  group User
    ../src/: HSI_calibration.c main.c stm32f10x_it.c
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group DOC
    ../: readme.txt

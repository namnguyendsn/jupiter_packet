# Keil uVision project Adj.uvproj, settings and files
target Jupiter V1.1 (ARM-ADS)
  device: STM32F100C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: JupiterV.10
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_LD_VL, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress 9
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Jupiter_config;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld_vl.s
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_pwr.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_bkp.c HSI_calibration.c stm32f10x_tim.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_crc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_usart.h
  group JupiterV1.1
    ../../../Jupiter_config/: jupiter_spi.c jupiter_595.c jupiter_uart.c jupiter_rtc.c jupiterHSICab.c common_config.h jupiter_flash.c stack.c timer_delay.c jupiter_pwm.c jupiter_crc.c jupiter_gpio.c key_check.c
    ../../../lcd/: LCD1.c
  group Main
    ../src/: stm32f10x_it.c main.c
    ../../../Libraries/: printf.c
    ../../../Jupiter_config/: JupiterV1_1.c
